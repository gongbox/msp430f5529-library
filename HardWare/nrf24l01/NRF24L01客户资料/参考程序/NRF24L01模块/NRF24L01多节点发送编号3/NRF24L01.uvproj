# Keil uVision project NRF24L01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NRF24L01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: NRF24L01.c Delay.c 发射.c DS18N02.c
