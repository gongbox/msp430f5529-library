# Keil uVision project NRF24L01模块.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: NRF24L01模块 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: NRF24L01.c DELAY.c 接收.c MAX232.c LCD12864.c
